# Keil uVision project fr8106h_2019_ncov.uvprojx, settings and files
target fr8106h_2019_ncov (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: flash +hex
  AfterMake: fromelf.exe --text -c -o ../flash/flash.txt ../obj/flash.axf
  AfterMake: fromelf.exe --bin -o ../flash/flash.bin ../obj/flash.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\component\include;..\core;..\library\include;..\drivers;..\library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../component/lib/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group user
    ./: proj_main.c section.c user_task.c user_timer.c ble_simple_peripheral.c
  group applications
    ./: app_sht3x.c app_lcd.c app_esp8266.c app_esp8266_wifista.c app_esp8266_ncov.c cJSON.c app_lcd_gui.c app_button.c multi_button.c
  group component
    ../component/: patch.c simple_gatt_service.c
    ../component/lib/: fr8010h_stack.lib
    ../component/include/: co_printf.h os_task.h os_timer.h os_mem.h os_msg_q.h
  group hardware
    ../drivers/: lcd.c sht3x.c sht3x_common.c sht3x_sw_i2c.c sht3x_sw_i2c_implementation.c
  group library
    ../library/: driver_adc.c driver_efuse.c driver_exti.c driver_i2s.c driver_iic.c driver_keyscan.c driver_pmu.c driver_pmu_qdec.c driver_rtc.c driver_timer.c driver_uart.c driver_wdt.c driver_ssp.c
  group core
    ../core/: core_cm3_isr.c app_boot_vectors.s
software components: CMSIS:CORE 5.1.2
